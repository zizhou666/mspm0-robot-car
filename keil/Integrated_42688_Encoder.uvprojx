# Keil uVision project Integrated_42688_Encoder.uvprojx, settings and files
target Integrated_42688_Encoder (6220000::V6.22::.\ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Integrated_42688_Encoder +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\;..\src;..\drivers;..\control;..\ui;..\external\mspm0-sdk\source;..\external\mspm0-sdk\source\third_party\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ..\external\mspm0-sdk\lib\driverlib.a
  group Application
    ../src/: main.c app_config.h user_config.h app_status.h wireless_test.c wireless_test.h settings_store.c settings_store.h
  group SysConfig
    ../: main.syscfg ti_msp_dl_config.c ti_msp_dl_config.h
  group Startup
    ../startup/: startup_mspm0g350x_uvision.s
  group Drivers
    ../drivers/: icm42688.c icm42688.h oled.c oled.h encoder.c encoder.h motor.c motor.h buttons.c buttons.h line_sensor.c line_sensor.h w25q64.c w25q64.h buzzer_rgb.c buzzer_rgb.h battery_monitor.c battery_monitor.h nrf24l01.c nrf24l01.h stm32_uart.c stm32_uart.h
  group Control
    ../control/: speed_pid.c speed_pid.h motor_debug.c motor_debug.h
  group UI
    ../ui/: ui.c ui.h
